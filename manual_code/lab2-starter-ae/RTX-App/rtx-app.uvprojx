# Keil uVision project rtx-app.uvprojx, settings and files
target RTX App SIM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtx-app-sim
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_0 DEBUG_1
  c include: ..\include;..\include\bsp\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x7000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group bsp
    ./src/bsp/LPC1768/: uart_polling.c
  group kernel
    ./src/kernel/: HAL.c k_mem.c k_rtx_init.c k_task.c main.c
  group libu
    ./src/libu/: printf.c
  group built-in tasks
    ./src/tasks/: null_task.c
  group Lib
    ../AE-Lib/Objects/SIM/: ae-lib-sim.lib
    ../AE-Lib/Objects/RAM/: ae-lib-ram.lib
target RTX App RAM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: rtx-app-ram
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_0 DEBUG_1
  c include: ..\include;..\include\bsp\LPC1768
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x10002000 size 0x5000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
