# Keil uVision project uart0irq_uart1polling.uvprojx, settings and files
target UART0 IRQ SIM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart0irq_uart1polling
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\include\bsp\LPC1768;..\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Documentation
    ./: Abstract.txt
  group System Code
    ./src/: main_irq.c
  group bsp
    ./src/bsp/LPC1768/: uart_irq.c uart_polling.c
  group libu
    ./src/libu/: printf.c
target UART0 IRQ RAM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: uart0irq_uart1polling
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\include;..\include\bsp\LPC1768
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
